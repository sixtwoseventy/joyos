#include <joyos.h>
#include <math.h>

int usetup() {
return 0;
}

// Lookup for exp(i/50)-1  (linearizes perceived LED brightness)
uint8_t lookup[278] = {0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 2, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 3, 4, 4, 4, 4, 4, 4, 4, 4, 4, 5, 5, 5, 5, 5, 5, 5, 5, 6, 6, 6, 6, 6, 6, 7, 7, 7, 7, 7, 7, 8, 8, 8, 8, 8, 8, 9, 9, 9, 9, 10, 10, 10, 10, 10, 11, 11, 11, 11, 12, 12, 12, 13, 13, 13, 13, 14, 14, 14, 15, 15, 15, 16, 16, 16, 17, 17, 17, 18, 18, 19, 19, 19, 20, 20, 21, 21, 22, 22, 23, 23, 24, 24, 25, 25, 26, 26, 27, 27, 28, 28, 29, 30, 30, 31, 32, 32, 33, 34, 34, 35, 36, 37, 37, 38, 39, 40, 41, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 58, 59, 60, 61, 63, 64, 65, 67, 68, 69, 71, 72, 74, 75, 77, 78, 80, 82, 83, 85, 87, 89, 90, 92, 94, 96, 98, 100, 102, 104, 106, 108, 111, 113, 115, 118, 120, 122, 125, 128, 130, 133, 136, 138, 141, 144, 147, 150, 153, 156, 159, 163, 166, 169, 173, 176, 180, 183, 187, 191, 195, 199, 203, 207, 211, 216, 220, 224, 229, 234, 238, 243, 248, 253};

void wave();
void flash();

int umain() {
    while(1){
        wave();
        flash();
    }

    return 0;
}

void wave() {
    uint16_t x[8] = {0,50,100,150,200,250,250,200};
    int8_t dir[8] = {1,1,1,1,1,1,-1,-1};
    for (uint16_t j = 0; j < 4000; j++) {
        for (int i = 0; i < 8; i++) {
            if (x[i] == 0 && dir[i] == -1) {
                dir[i] = 1;
            } else if (x[i] == 277 && dir[i] == 1) {
                dir[i] = -1;
            }
            x[i] = x[i] + dir[i];
            uint8_t v = lookup[x[i]];
            digital_write_pwm(i, v);
        }

        pause(2);
    }
}

void flash() {
    uint8_t i;

    for (i = 0; i < 8; i++) {
        digital_write(i, 0);
    }

    srand(get_time());

    for (uint8_t i = 0; i < 75; i++) {
        uint8_t port = rand() % 8;
        digital_write(port, 1);
        pause(40);
        digital_write(port, 0);
        pause(90);
    }
}
